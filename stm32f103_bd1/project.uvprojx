# Keil uVision project project.uvprojx, settings and files
target rtthread-stm32 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, RT_USING_ARM_LIBC, USE_STDPERIPH_DRIVER
  c include: ..\stdlib_f3\STM32F10x_StdPeriph_Driver\inc;..\stdlib_f3\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\stdlib_f3\CMSIS\CM3\CoreSupport;applications;.;drivers;easyflash\inc;ioLibrary\Ethernet;ioLibrary\Internet\DHCP;ioLibrary\Internet\DNS;..\..\rt-thread_stdio\include;..\..\rt-thread_stdio\libcpu\arm\cortex-m3;..\..\rt-thread_stdio\libcpu\arm\common;..\..\rt-thread_stdio\components\dfs\include;..\..\rt-thread_stdio\components\drivers\include;..\..\rt-thread_stdio\components\drivers\include;..\..\rt-thread_stdio\components\libc\cruntime\armlibc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --keep *.o(.rti_fn.*)
  group STM32_StdPeriph
    ../stdlib_f3/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../stdlib_f3/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    ../stdlib_f3/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../stdlib_f3/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Applications
    applications/: application.c atcmd.c net.c proto.c relay.c startup.c wkparm.c zaz.c
  group Drivers
    drivers/: board.c stm32f10x_it.c led.c usart.c spiHandler.c
  group EasyFlash
    easyflash/src/: easyflash.c ef_env.c ef_env_wl.c ef_utils.c
    easyflash/port/: ef_port.c
  group ioLibrary
    ioLibrary/Ethernet/: socket.c wizchip_conf.c
    ioLibrary/Ethernet/W5500/: w5500.c
    ioLibrary/Internet/DHCP/: dhcp.c
    ioLibrary/Internet/DNS/: dns.c
    ./ioLibrary/Ethernet/: sockutil.c
  group Kernel
    ../../rt-thread_stdio/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M3
    ../../rt-thread_stdio/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../rt-thread_stdio/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../rt-thread_stdio/components/dfs/src/: dfs.c dfs_file.c dfs_posix.c poll.c select.c
  group DeviceDrivers
    ../../rt-thread_stdio/components/drivers/src/: completion.c dataqueue.c device.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread_stdio/components/drivers/tty/: serial.c
  group libc
    ../../rt-thread_stdio/components/libc/cruntime/armlibc/: dup.c libc_syms.c mem_std.c stubs.c time.c
