# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32f4xx (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: RT_USING_ARM_LIBC, USE_STDPERIPH_DRIVER
  c include: ..\stdlib_f4\STM32F4xx_StdPeriph_Driver\inc;..\stdlib_f4\CMSIS\ST\STM32F4xx\Include;..\stdlib_f4\CMSIS\Include;applications;.;drivers;..\..\rt-thread_stdio\include;..\..\rt-thread_stdio\libcpu\arm\cortex-m4;..\..\rt-thread_stdio\libcpu\arm\common;..\..\rt-thread_stdio\components\dfs\include;..\..\rt-thread_stdio\components\dfs\filesystems\devfs;..\..\rt-thread_stdio\components\drivers\include;..\..\rt-thread_stdio\components\drivers\include;..\..\rt-thread_stdio\components\drivers\rtc;..\..\rt-thread_stdio\components\drivers\include;..\..\rt-thread_stdio\components\drivers\include;..\..\rt-thread_stdio\components\finsh;..\..\rt-thread_stdio\components\libc\cruntime\armlibc;..\..\rt-thread_stdio\components\net\lwip-2.0.2\src;..\..\rt-thread_stdio\components\net\lwip-2.0.2\src\include;..\..\rt-thread_stdio\components\net\lwip-2.0.2\src\include\ipv4;..\..\rt-thread_stdio\components\net\lwip-2.0.2\src\arch\include;..\..\rt-thread_stdio\components\net\lwip-2.0.2\src\include\netif
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group STM32_StdPeriph
    ../stdlib_f4/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../stdlib_f4/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../stdlib_f4/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c stm32f4xx_it.c usart.c stm32f4xx_eth.c drv_rtc.c drv_k9f1g08.c
  group Kernel
    ../../rt-thread_stdio/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M4
    ../../rt-thread_stdio/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../rt-thread_stdio/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../rt-thread_stdio/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../rt-thread_stdio/components/dfs/filesystems/devfs/: devfs.c fifo.c
  group DeviceDrivers
    ../../rt-thread_stdio/components/drivers/mtd/: mtdcore.c mtd_nand.c
    ../../rt-thread_stdio/components/drivers/pipe/: pipe.c
    ../../rt-thread_stdio/components/drivers/rtc/: rtc.c
    ../../rt-thread_stdio/components/drivers/src/: completion.c dataqueue.c device.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread_stdio/components/drivers/tty/: serial.c
  group finsh
    ../../rt-thread_stdio/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../rt-thread_stdio/components/libc/cruntime/armlibc/: dup.c libc_syms.c mem_std.c stubs.c time.c
  group lwIP
    ../../rt-thread_stdio/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../rt-thread_stdio/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../rt-thread_stdio/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../rt-thread_stdio/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../rt-thread_stdio/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
