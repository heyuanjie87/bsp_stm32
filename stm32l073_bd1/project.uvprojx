# Keil uVision project project.uvprojx, settings and files
target rtthread-stm32 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L073CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, STM32L0X2, RT_USING_ARM_LIBC
  c include: ..\hallib_l0\STM32L0xx_HAL_Driver\Inc;..\hallib_l0\CMSIS\Device\ST\STM32L0xx\Include;..\hallib_l0\CMSIS\Include;applications;.;drivers;drivers..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\rt-thread_stdio\include;..\..\rt-thread_stdio\libcpu\arm\cortex-m0;..\..\rt-thread_stdio\libcpu\arm\common;..\..\rt-thread_stdio\components\dfs\include;..\..\rt-thread_stdio\components\drivers\include;..\..\rt-thread_stdio\components\drivers\include;..\..\rt-thread_stdio\components\finsh;..\..\rt-thread_stdio\components\libc\cruntime\armlibc;..\..\rt-thread_stdio\components\utilities\shcmd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group STM32_HAL
    ../hallib_l0/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
    ../hallib_l0/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_wwdg.c
    ../hallib_l0/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l073xx.s
  group Applications
    applications/: main.c
  group Drivers
    drivers/: board.c stm32l0xx_it.c usart.c
  group Kernel
    ../../rt-thread_stdio/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M0
    ../../rt-thread_stdio/libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
    ../../rt-thread_stdio/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../rt-thread_stdio/components/dfs/src/: dfs.c dfs_file.c dfs_posix.c poll.c select.c
  group DeviceDrivers
    ../../rt-thread_stdio/components/drivers/src/: completion.c dataqueue.c device.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread_stdio/components/drivers/tty/: serial.c
  group finsh
    ../../rt-thread_stdio/components/finsh/: shell.c symbol.c cmd.c msh.c msh_file.c
  group libc
    ../../rt-thread_stdio/components/libc/cruntime/armlibc/: dup.c libc_syms.c mem_std.c stubs.c time.c
